options:
  parameters:
    generate_options: qt_gui
    id: punto_1
    output_language: python
    title: Qpsk
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: (3+0j,0+3j,-3+0j,0-3j)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Samp_rate
  id: variable
  parameters:
    value: Sps*Rs
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: (3+0j,0+3j,-3+0j,0-3j)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: ruido
  id: variable_qtgui_range
  parameters:
    label: ruido
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RX
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: ruido
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcomu208/Documentos/labComu_Grupo_4_B1_2023-2/Comu2-B1-2023-2/proyecto/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: Sps
    taps: h
    type: ccf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Constelacion enviada"'
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Constelacion recibida"'
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: Samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Señal modulada en frecuencia"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal modulada"'
    size: '1024'
    srate: Samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal inicial"'
    size: '1024'
    srate: Samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal demodulada"'
    size: '1024'
    srate: Samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal recibida"'
    size: '1024'
    srate: Samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: Sps
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: Sps
    interp: '1'
    taps: h
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: P0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: P0
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0_1, '0', audio_sink_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_float_to_char_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_2, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_1, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', rational_resampler_xxx_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [fir_filter_xxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_1, '0']
- [rational_resampler_xxx_1, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_1, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_2, '0', digital_constellation_decoder_cb_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_const_sink_x_0_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
