options:
  parameters:
    generate_options: qt_gui
    id: punto_1
    output_language: python
    title: Qpsk
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
  states: {}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Samp_rate
  id: variable
  parameters:
    value: Sps*Rs
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: (0.77+0.77j,-0.77+0.77j,-0.77-0.77j,0.77-0.77j)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Constelacion recibida"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal demodulada"'
    size: '1024'
    srate: Samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal recibida"'
    size: '1024'
    srate: Samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: Sps
    interp: '1'
    taps: h
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: Samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0_1, '0', audio_sink_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_2, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [rational_resampler_xxx_2, '0', digital_constellation_decoder_cb_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_const_sink_x_0_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_time_sink_x_2, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
