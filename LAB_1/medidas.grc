options:
  parameters:
    category: Medidas_practica_1
    generate_options: hb_qt_gui
    id: medidas
    output_language: python
    title: prueba_1_medidas
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      class blk (gr. sync_block ):

      	def __init__( self ): # only default arguments here
      		gr.sync_block.__init__(
      			self ,
      			name = 'Promedios_de_tiempos ', # will show up in GRC
      			in_sig =[np.float32],
      			out_sig=[np.float32 ,np.float32 ,np.float32 ,np.float32 ,np.float32 ]
      		)

      		self.acum_anterior = 0
      		self.Ntotales = 0
      		self.acum_anterior1 = 0
      		self.acum_anterior2 = 0


      	def work (self, input_items, output_items):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial



      		# Calculo del promedio
      		N = len(x)
      		self.Ntotales = self.Ntotales + N
      		acumulado = self.acum_anterior + np.cumsum(x)
      		self.acum_anterior = acumulado[N -1]
      		y0[:]=acumulado/self.Ntotales
      		
      		# Calculo de la media cuadratica
      		x2=np.multiply(x,x)
      		acumulado1 = self.acum_anterior1 + np.cumsum(x2)
      		self.acum_anterior1 = acumulado1[N-1]
      		y1[:] = acumulado1/self.Ntotales
      		
      		# Calculo de la RMS
      		y2[:] = np.sqrt(y1)
      		
      		# Calculo de la potencia promedio
      		y3[:] = np.multiply(y2 ,y2)
      		
      		# Calculo de la desviacion estandar
      		x3 = np.multiply(x-y0 ,x-y0)
      		acumulado2 = self.acum_anterior2 + np.cumsum(x3)
      		self.acum_anterior2 = acumulado2[N -1]
      		y4[:] = np. sqrt( acumulado2/self.Ntotales )
      		return len(x)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS señal"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"media cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia promedio señal"'
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviaciòn estàndar"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_0, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_1, '0']
- [epy_block_0, '2', qtgui_number_sink_0, '0']
- [epy_block_0, '3', qtgui_number_sink_0_2, '0']
- [epy_block_0, '4', qtgui_number_sink_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
